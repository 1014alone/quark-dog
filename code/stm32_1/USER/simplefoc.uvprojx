# Keil uVision project simplefoc.uvprojx, settings and files
target simplefoc (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: quark +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\RT-THREAD\components\finsh;..\RT-THREAD\include;..\RT-THREAD\include\libc;..\MY_RTTHREAD;..\USER;..\HARDWARE\foc;..\HARDWARE
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c rtconfig.h board.c board.h
  group HARDWARE
    ../HARDWARE/: motor_init.c adc.c
    ../../../../quark-simplefoc/CODE/simplefoc_f1_rtthread/HARDWARE/: as5600.c myiic.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dma.c
  group README
    ../: README.TXT
  group RTT-SOURCE
    ../RT-THREAD/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group RTT-PORTS
    ../RT-THREAD/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group MY-RTTHREAD
    ../MY_RTTHREAD/: thread_manage.c
  group FOC
    ../HARDWARE/foc/: foc.c KalmanFilter.c pid.c
